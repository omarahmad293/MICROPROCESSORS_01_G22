# Keil uVision project newproject.uvproj, settings and files
target Project (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: newproject
  c flags: Optim=1
  c include: ..\..\MCArm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: DIO.c DIO.h MCAL.c MCAL.h startup_TM4C123.s tm4c123gh6pm.h typedefs.h __main.c Port_Init.c Port_SetPinDirection.c Port_SetPull.c LCD.h PushButton.h PushButton.c Port_SetPinPullUp.c Timer_Delay.c timer_init.c GPIO.h timer.h includes.h LCD.c
