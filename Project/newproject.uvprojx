# Keil uVision project newproject.uvprojx, settings and files
target Project (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: newproject
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\MCArm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: DIO.c DIO.h MCAL.c MCAL.h startup_TM4C123.s tm4c123gh6pm.h typedefs.h __main.c Port_Init.c Port_SetPinDirection.c Port_SetPull.c LCD.h PushButton.h PushButton.c Port_SetPinPullUp.c Timer_Delay.c timer_init.c GPIO.h timer.h includes.h
software components: CMSIS:CORE 5.1.2
